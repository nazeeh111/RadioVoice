options:
  parameters:
    author: nazeeh111
    generate_options: qt_gui
    id: laser_zmod
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: radiovoice_imports
  id: import
  parameters:
    imports: from radiovoice_paths import output_file, input_file
  states: {}
- name: output_path
  id: variable
  parameters:
    value: ''''''
  states: {}
- name: bb_gain
  id: variable_qtgui_range
  parameters:
    rangeType: int
    start: '1'
    step: '1'
    stop: '64'
    value: '10'
  states: {}
- name: decim
  id: variable
  parameters:
    value: int(samp_rate/samp_rate_au)
  states: {}
- name: end_decim
  id: variable
  parameters:
    value: int(mid_sr/samp_rate_au)
  states: {}
- name: end_sr
  id: variable
  parameters:
    value: int(mid_sr/end_decim)
  states: {}
- name: gain_hp
  id: variable_qtgui_range
  parameters:
    rangeType: int
    start: '1'
    step: '1'
    stop: '100'
    value: '10'
  states: {}
- name: gain_xlat
  id: variable_qtgui_range
  parameters:
    start: '1'
    step: '1'
    stop: '100'
    value: '10'
  states: {}
- name: hpf
  id: variable
  parameters:
    value: '100'
  states: {}
- name: if_gain
  id: variable_qtgui_range
  parameters:
    rangeType: int
    start: '1'
    step: '1'
    stop: '64'
    value: '10'
  states: {}
- name: laser_freq
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '3050000'
    value: '0'
  states: {}
- name: lpf
  id: variable
  parameters:
    value: 20000*2.4
  states: {}
- name: mid_decim
  id: variable
  parameters:
    value: int(samp_rate/samp_rate_au/5)
  states: {}
- name: mid_sr
  id: variable
  parameters:
    value: int(samp_rate/mid_decim)
  states: {}
- name: rf_freq
  id: variable
  parameters:
    value: laser_freq+rf_offset+upconvert_freq
  states: {}
- name: rf_gain
  id: variable_qtgui_range
  parameters:
    rangeType: int
    start: '0'
    step: '1'
    stop: '100'
    value: '0'
  states: {}
- name: rf_offset
  id: variable
  parameters:
    value: 30e3*10
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: samp_rate_au * 23
  states: {}
- name: samp_rate_au
  id: variable
  parameters:
    value: '96000'
  states: {}
- name: trw
  id: variable
  parameters:
    value: '5000'
  states: {}
- name: up_offset
  id: variable
  parameters:
    value: '0'
  states: {}
- name: upconvert_freq
  id: variable
  parameters:
    value: '125000000'
  states: {}
- name: analog_am_demod_cf_0
  id: analog_am_demod_cf
  parameters:
    audio_decim: end_decim
    audio_pass: lpf
    audio_stop: lpf+1000
    chan_rate: mid_sr
  states: {state: disabled}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: samp_rate_au
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {state: disabled}
- name: blocks_correctiq_0
  id: blocks_correctiq
  parameters: {}
  states: {}
- name: blocks_wavfile_sink_0
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample1: FORMAT_PCM_16
    file: ${output_path}
    format: FORMAT_WAV
    samp_rate: samp_rate_au
  states: {state: disabled}
- name: freq_xlating_fir_filter_xxx_0_0_1
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: laser_freq-laser_freq-rf_offset+up_offset
    decim: mid_decim
    samp_rate: samp_rate
    taps: firdes.band_pass(gain_xlat, samp_rate, 30, lpf, trw)
    type: ccc
  states: {}
- name: high_pass_filter_1
  id: high_pass_filter
  parameters:
    cutoff_freq: '60'
    decim: '1'
    gain: gain_hp
    samp_rate: samp_rate_au
    type: fir_filter_fff
    width: '100'
    win: window.WIN_HAMMING
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: hackrf=0
    bb_gain0: bb_gain
    freq0: rf_freq
    gain0: rf_gain
    gain_mode0: 'False'
    if_gain0: if_gain
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: mid_sr
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: rf_freq
    fftsize: '1024'
    grid: 'True'
    type: complex
    update_time: '0.25'
  states: {}
- name: qtgui_freq_sink_x_0_0_0_0_0_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate_au
    fc: '0'
    fftsize: '2048'
    freqhalf: 'False'
    grid: 'True'
    label1: hp+xlat/dec
    name: xlat freq
    norm_window: 'True'
    type: float
    update_time: '0.1'
  states: {}

connections:
- [analog_am_demod_cf_0, '0', high_pass_filter_1, '0']
- [blocks_complex_to_float_0, '0', high_pass_filter_1, '0']
- [blocks_complex_to_mag_0, '0', high_pass_filter_1, '0']
- [blocks_correctiq_0, '0', blocks_complex_to_float_0, '0']
- [freq_xlating_fir_filter_xxx_0_0_1, '0', analog_am_demod_cf_0, '0']
- [freq_xlating_fir_filter_xxx_0_0_1, '0', blocks_complex_to_mag_0, '0']
- [freq_xlating_fir_filter_xxx_0_0_1, '0', blocks_correctiq_0, '0']
- [freq_xlating_fir_filter_xxx_0_0_1, '0', qtgui_freq_sink_x_0, '0']
- [high_pass_filter_1, '0', audio_sink_0, '0']
- [high_pass_filter_1, '0', blocks_wavfile_sink_0, '0']
- [high_pass_filter_1, '0', qtgui_freq_sink_x_0_0_0_0_0_1, '0']
- [osmosdr_source_0, '0', freq_xlating_fir_filter_xxx_0_0_1, '0']
- [osmosdr_source_0, '0', qtgui_freq_sink_x_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
