options:
  parameters:
    author: nazeeh111
    generate_options: qt_gui
    id: saleae_demod
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: radiovoice_imports
  id: import
  parameters:
    imports: from radiovoice_paths import output_file, input_file
  states: {}
- name: output_path
  id: variable
  parameters:
    value: output_file('saleae_demod')
  states: {}
- name: input_path
  id: variable
  parameters:
    value: input_file()
  states: {}
- name: decim
  id: variable
  parameters:
    value: int(samp_rate/samp_rate_au)
  states: {}
- name: end_decim
  id: variable
  parameters:
    value: int(mid_sr/samp_rate_au)
  states: {}
- name: end_sr
  id: variable
  parameters:
    value: int(mid_sr/end_decim)
  states: {}
- name: gain_hp
  id: variable_qtgui_range
  parameters:
    rangeType: int
    start: '1'
    step: '1'
    stop: '100'
    value: '10'
  states: {}
- name: gain_xlat
  id: variable_qtgui_range
  parameters:
    start: '1'
    step: '1'
    stop: '100'
    value: '10'
  states: {}
- name: hpf
  id: variable
  parameters:
    value: '100'
  states: {}
- name: laser_freq
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '3050000'
    value: 100e3
  states: {}
- name: lpf
  id: variable
  parameters:
    value: '20000'
  states: {}
- name: mid_decim
  id: variable
  parameters:
    value: int(samp_rate/samp_rate_au/11)
  states: {}
- name: mid_sr
  id: variable
  parameters:
    value: int(samp_rate/mid_decim)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '781250'
  states: {}
- name: samp_rate_au
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: trw
  id: variable
  parameters:
    value: 5000/5
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: '65536'
    rate: '1e-4'
    reference: '1.0'
    type: float
  states: {state: disabled}
- name: analog_agc_xx_0_0
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: '65536'
    rate: '1e-4'
    reference: '1.0'
    type: float
  states: {}
- name: analog_am_demod_cf_0
  id: analog_am_demod_cf
  parameters:
    audio_decim: end_decim
    audio_pass: lpf
    audio_stop: lpf+1000
    chan_rate: mid_sr
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: end_sr
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: int(samp_rate/samp_rate_au)
    gain: '1'
    high_cutoff_freq: '10000'
    low_cutoff_freq: '20'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '10'
    win: window.WIN_HAMMING
  states: {state: disabled}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: ${input_path}
    repeat: 'False'
    type: float
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: blocks_wavfile_sink_0
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample1: FORMAT_PCM_16
    file: ${output_path}
    format: FORMAT_WAV
    samp_rate: samp_rate_au
  states: {}
- name: dc_blocker_xx_0
  id: dc_blocker_xx
  parameters:
    length: 32*8
    long_form: 'True'
    type: ff
  states: {}
- name: freq_xlating_fir_filter_xxx_0_0_1
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: laser_freq
    decim: mid_decim
    samp_rate: samp_rate
    taps: firdes.band_pass(gain_xlat, samp_rate, 30, lpf, trw)
    type: fcf
  states: {}
- name: high_pass_filter_1
  id: high_pass_filter
  parameters:
    cutoff_freq: '60'
    decim: '1'
    gain: gain_hp
    samp_rate: end_sr
    type: fir_filter_fff
    width: 100/10
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: mid_sr
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    name: xlat+bp
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '512'
    grid: 'True'
    name: dc block
    type: float
    update_time: '0.25'
  states: {}
- name: qtgui_freq_sink_x_0_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '512'
    grid: 'True'
    name: raw
    type: float
    update_time: '0.25'
  states: {}
- name: qtgui_freq_sink_x_0_0_0_0_0_1
  id: qtgui_freq_sink_x
  parameters:
    bw: end_sr
    fc: '0'
    fftsize: '1024'
    freqhalf: 'False'
    grid: 'True'
    label1: hp+xlat/dec
    name: xlat freq
    norm_window: 'True'
    type: float
    update_time: '0.1'
  states: {}
- name: qtgui_freq_sink_x_0_0_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '512'
    grid: 'True'
    name: agc
    type: float
    update_time: '0.25'
  states: {}
- name: qtgui_freq_sink_x_0_1
  id: qtgui_freq_sink_x
  parameters:
    average: '0.05'
    bw: end_sr
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    name: am demod
    type: float
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: end_sr
    fc: '0'
    fftsize: '1024'
    type: float
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: end_sr
    color1: '5'
    fc: '0'
    fftsize: '1024'
    freqhalf: 'False'
    type: float
  states: {}

connections:
- [analog_agc_xx_0, '0', band_pass_filter_0, '0']
- [analog_agc_xx_0_0, '0', freq_xlating_fir_filter_xxx_0_0_1, '0']
- [analog_agc_xx_0_0, '0', qtgui_freq_sink_x_0_0_1, '0']
- [analog_am_demod_cf_0, '0', high_pass_filter_1, '0']
- [analog_am_demod_cf_0, '0', qtgui_freq_sink_x_0_1, '0']
- [band_pass_filter_0, '0', audio_sink_0, '0']
- [band_pass_filter_0, '0', blocks_wavfile_sink_0, '0']
- [band_pass_filter_0, '0', qtgui_freq_sink_x_0_0_0_0_0_1, '0']
- [band_pass_filter_0, '0', qtgui_sink_x_0, '0']
- [band_pass_filter_0, '0', qtgui_waterfall_sink_x_0, '0']
- [blocks_file_source_0, '0', blocks_throttle2_0, '0']
- [blocks_throttle2_0, '0', analog_agc_xx_0, '0']
- [blocks_throttle2_0, '0', dc_blocker_xx_0, '0']
- [blocks_throttle2_0, '0', qtgui_freq_sink_x_0_0_0, '0']
- [dc_blocker_xx_0, '0', analog_agc_xx_0_0, '0']
- [dc_blocker_xx_0, '0', qtgui_freq_sink_x_0_0, '0']
- [freq_xlating_fir_filter_xxx_0_0_1, '0', analog_am_demod_cf_0, '0']
- [freq_xlating_fir_filter_xxx_0_0_1, '0', qtgui_freq_sink_x_0, '0']
- [high_pass_filter_1, '0', audio_sink_0, '0']
- [high_pass_filter_1, '0', blocks_wavfile_sink_0, '0']
- [high_pass_filter_1, '0', qtgui_freq_sink_x_0_0_0_0_0_1, '0']
- [high_pass_filter_1, '0', qtgui_sink_x_0, '0']
- [high_pass_filter_1, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
