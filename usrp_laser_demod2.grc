options:
  parameters:
    author: nazeeh111
    generate_options: qt_gui
    id: usrp_laser_demod2
    output_language: python
    title: samy laser mic usrp upconverted + modulated
  states: {}

blocks:
- name: radiovoice_imports
  id: import
  parameters:
    imports: from radiovoice_paths import output_file, input_file
  states: {}
- name: output_path
  id: variable
  parameters:
    value: output_file('usrp_laser_demod2')
  states: {}
- name: end_decim
  id: variable
  parameters:
    value: int(mid_sr/samp_rate_au)
  states: {}
- name: end_sr
  id: variable
  parameters:
    value: int(mid_sr/end_decim)
  states: {}
- name: gain_hp
  id: variable_qtgui_range
  parameters:
    rangeType: int
    start: '1'
    step: '1'
    stop: '100'
    value: '15'
  states: {}
- name: gain_xlat
  id: variable_qtgui_range
  parameters:
    start: '1'
    step: '1'
    stop: '100'
    value: '2'
  states: {}
- name: hpf
  id: variable_qtgui_range
  parameters:
    rangeType: int
    start: '1'
    step: '1'
    stop: '10000'
    value: '60'
  states: {}
- name: hpf_trw
  id: variable_qtgui_range
  parameters:
    rangeType: int
    start: '10'
    step: '10'
    stop: '10000'
    value: '50'
  states: {}
- name: laser_freq
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '3050000'
    value: 150e3
  states: {}
- name: lpf
  id: variable
  parameters:
    value: 20000/4*2
  states: {}
- name: mid_decim
  id: variable
  parameters:
    value: int(samp_rate/samp_rate_au/8)
  states: {}
- name: mid_sr
  id: variable
  parameters:
    value: int(samp_rate/mid_decim)
  states: {}
- name: rf_freq
  id: variable
  parameters:
    value: laser_freq+rf_offset+upconvert_freq
  states: {}
- name: rf_offset
  id: variable
  parameters:
    value: 50e3
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: samp_rate_au * 10 *2
  states: {}
- name: samp_rate_au
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: trw
  id: variable
  parameters:
    value: '1000'
  states: {}
- name: up_offset
  id: variable
  parameters:
    value: '0'
  states: {}
- name: upconvert_freq
  id: variable
  parameters:
    value: '125000000'
  states: {}
- name: analog_am_demod_cf_0
  id: analog_am_demod_cf
  parameters:
    audio_decim: end_decim
    audio_pass: lpf
    audio_stop: lpf+1000
    chan_rate: mid_sr
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: samp_rate_au
  states: {}
- name: blocks_wavfile_sink_0
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample1: FORMAT_PCM_16
    file: ${output_path}
    format: FORMAT_WAV
    samp_rate: samp_rate_au
  states: {}
- name: freq_xlating_fir_filter_xxx_0_0_1
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: laser_freq-laser_freq-rf_offset+up_offset
    decim: mid_decim
    samp_rate: samp_rate
    taps: firdes.band_pass(gain_xlat, samp_rate, 30, lpf, trw)
    type: ccc
  states: {}
- name: high_pass_filter_1
  id: high_pass_filter
  parameters:
    cutoff_freq: hpf
    decim: '1'
    gain: gain_hp
    samp_rate: samp_rate_au
    type: fir_filter_fff
    width: hpf_trw
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: mid_sr
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    name: xlat fir
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: rf_freq
    fftsize: '512'
    grid: 'True'
    name: usrp
    type: complex
    update_time: '0.25'
  states: {}
- name: qtgui_freq_sink_x_0_0_0_0_0_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate_au
    fc: '0'
    fftsize: '512'
    freqhalf: 'False'
    grid: 'True'
    label1: hp+xlat/dec
    name: hp
    norm_window: 'True'
    type: float
    update_time: '0.1'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate_au
    fc: '0'
    fftsize: '512'
    freqhalf: 'False'
    type: float
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    bw0: samp_rate
    center_freq0: rf_freq
    rx_agc0: Enabled
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_am_demod_cf_0, '0', high_pass_filter_1, '0']
- [freq_xlating_fir_filter_xxx_0_0_1, '0', analog_am_demod_cf_0, '0']
- [freq_xlating_fir_filter_xxx_0_0_1, '0', qtgui_freq_sink_x_0, '0']
- [high_pass_filter_1, '0', audio_sink_0, '0']
- [high_pass_filter_1, '0', blocks_wavfile_sink_0, '0']
- [high_pass_filter_1, '0', qtgui_freq_sink_x_0_0_0_0_0_1, '0']
- [high_pass_filter_1, '0', qtgui_waterfall_sink_x_0, '0']
- [uhd_usrp_source_0, '0', freq_xlating_fir_filter_xxx_0_0_1, '0']
- [uhd_usrp_source_0, '0', qtgui_freq_sink_x_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
